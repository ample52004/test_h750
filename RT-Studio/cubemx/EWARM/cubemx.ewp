# IAR project cubemx.ewp, settings and files
configuration cubemx (ARM, debug)
  General.OGChipSelectEditMenu: STM32H750XB ST STM32H750XB
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 6
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32H750xx
  ICCARM.CCIncludePath2: ../Inc; ../Drivers/STM32H7xx_HAL_Driver/Inc; ../Drivers/STM32H7xx_HAL_Driver/Inc/Legacy; ../Drivers/CMSIS/Device/ST/STM32H7xx/Include; ../Drivers/CMSIS/Include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: cubemx.hex
  ILINK.IlinkOutputFile: cubemx.out
  ILINK.IlinkIcfFile: stm32h750xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32h750xx.s
  group Application/User
    ../F:/RT_Thread_Win/h750-rt-thread/h750-rt-thread-main/RT-Studio/cubemx/Src/: main.c gpio.c spi.c usart.c stm32h7xx_it.c stm32h7xx_hal_msp.c
  group Application/User/F:/RT_Thread_Win/h750-rt-thread/h750-rt-thread-main/RT-Studio/cubemx
    ../F:/RT_Thread_Win/h750-rt-thread/h750-rt-thread-main/RT-Studio/cubemx/Src/: main.c gpio.c spi.c usart.c stm32h7xx_it.c stm32h7xx_hal_msp.c
  group Drivers/STM32H7xx_HAL_Driver
    ../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal_cortex.c stm32h7xx_hal_spi.c stm32h7xx_hal_spi_ex.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_hsem.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_mdma.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_exti.c stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c
  group Drivers/CMSIS
    ../Src/: system_stm32h7xx.c
