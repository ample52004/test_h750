# Keil uVision project lwip-rtt-stm32.uvprojx, settings and files
target lwip-rtt-stm32 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F207VE STMicroelectronics
  pack: Keil.STM32F2xx_DFP.1.0.4
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: lwip-rtt-stm32
  AfterMake: fromelf.exe --bin -o "$L@L.bin" "#L"
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: ..\user\app;..\lib\rt-thread-3.1.3\include;..\lib\CMSIS;..\lib\STM32F2xx_StdPeriph_Driver\inc;..\lib\STM32F2xx_StdPeriph_Driver\STM32F2x7_ETH_Driver\inc;..\lib\rt-thread-3.1.3\port;..\lib\rt-thread-3.1.3\components\finsh;..\user\drv;..\user\api;..\lib\LWIP;..\lib\LWIP\arch;..\lib\LWIP\lwip_app\lwip_comm;..\lib\LWIP\lwip-1.4.1\src\include;..\lib\LWIP\lwip-1.4.1\src\include\ipv4;..\lib\LWIP\lwip-1.4.1\src\include\lwip;..\lib\LWIP\lwip-1.4.1\src\include\netif;..\lib\LWIP\lwip-1.4.1\src\include\ipv4\lwip;..\lib\LWIP\lwip-1.4.1\src\include\posix;..\lib\LWIP\lwip-1.4.1\src\include\posix\sys;..\lib\LWIP\lwip_app\udp_demo;..\lib\LWIP\lwip_app\tcp_client_demo
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x70000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group app
    ../user/app/: main.c cycle_task.c
  group api
    ../user/api/: api_debug.c dp83848.c
  group drv
    ../lib/CMSIS/: stm32f2xx_conf.h
    ../lib/STM32F2xx_StdPeriph_Driver/STM32F2x7_ETH_Driver/inc/: stm32f2x7_eth_conf.h
    ../user/drv/: drv_common.h drv_usart.c drv_eth_mac.c drv_pin.c
  group lib
    ../lib/STM32F2xx_StdPeriph_Driver/src/: misc.c stm32f2xx_adc.c stm32f2xx_can.c stm32f2xx_crc.c stm32f2xx_cryp.c stm32f2xx_cryp_aes.c stm32f2xx_cryp_des.c stm32f2xx_cryp_tdes.c stm32f2xx_dac.c stm32f2xx_dbgmcu.c stm32f2xx_dcmi.c stm32f2xx_dma.c stm32f2xx_exti.c stm32f2xx_flash.c stm32f2xx_fsmc.c stm32f2xx_gpio.c stm32f2xx_hash.c stm32f2xx_hash_md5.c stm32f2xx_hash_sha1.c stm32f2xx_i2c.c stm32f2xx_iwdg.c stm32f2xx_pwr.c stm32f2xx_rcc.c stm32f2xx_rng.c stm32f2xx_rtc.c stm32f2xx_sdio.c stm32f2xx_spi.c stm32f2xx_syscfg.c stm32f2xx_tim.c stm32f2xx_usart.c stm32f2xx_wwdg.c
    ../lib/STM32F2xx_StdPeriph_Driver/STM32F2x7_ETH_Driver/src/: stm32f2x7_eth.c
  group cmsis
    ../lib/CMSIS/: core_cm3.c stm32f2xx_it.c system_stm32f2xx.c startup_stm32f2xx.s
  group rtos/port
    ../lib/rt-thread-3.1.3/port/: board.c rtconfig.h
  group rtos/cpu
    ../lib/rt-thread-3.1.3/libcpu/arm/cortex-m3/: context_rvds.S cpuport.c
  group rtos/finsh
    ../lib/rt-thread-3.1.3/components/finsh/: cmd.c msh.c shell.c
  group rtos/scr
    ../lib/rt-thread-3.1.3/src/: clock.c components.c cpu.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c object.c scheduler.c slab.c thread.c timer.c
  group lwip/comm
    ../lib/LWIP/lwip_app/lwip_comm/: lwipopts.h lwip_comm.c
    ../lib/LWIP/lwip_app/udp_demo/: udp_demo.c netconn_udp_demo.c
    ../lib/LWIP/lwip_app/tcp_client_demo/: tcp_client_demo.c netconn_tcp_client_demo.c
  group lwip/arch
    ../lib/LWIP/arch/: sys_arch.c
  group lwip/netif
    ../lib/LWIP/lwip-1.4.1/src/netif/: etharp.c ethernetif.c
  group lwip/core
    ../lib/LWIP/lwip-1.4.1/src/include/lwip/: opt.h
    ../lib/LWIP/lwip-1.4.1/src/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
    ../lib/LWIP/lwip-1.4.1/src/core/: def.c dhcp.c dns.c init.c mem.c memp.c netif.c pbuf.c raw.c stats.c tcp.c tcp_in.c tcp_out.c timers.c udp.c sys.c
  group lwip/api
    ../lib/LWIP/lwip-1.4.1/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
  group doc
    ../doc/: readme.txt
